# Author: Aananth C N
# Date: 27 May 2021, 9:54 PM

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
